# Keil uVision project Nucleo-L432KC-pdmgenerator.uvprojx, settings and files
target Nucleo-L432KC-pdmgenerator (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L432KCUx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.1.5.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: Nucleo-L432KC-pdmgenerator
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L432xx
  c misc: --C99
  c include: ../Inc;  ../Drivers/STM32L4xx_HAL_Driver/Inc;  ../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;  ../Drivers/CMSIS/Device/ST/STM32L4xx/Include;  ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: stm32l4xx_it.c main.c stm32l4xx_hal_msp.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_spi.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal.c stm32l4xx_hal_i2c.c stm32l4xx_hal_pwr.c stm32l4xx_hal_tim.c stm32l4xx_hal_uart.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_flash.c stm32l4xx_hal_dma_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Application/MDK-ARM
    ./: startup_stm32l432xx.s
software components: CMSIS:CORE 4.1.0
